# Keil uVision project STM32-DEMO.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32-DEMO +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c misc: --c99
  c include: ..\CMSIS;..\USER;..\FWlib\inc;..\FWlib\src;..\BSP\CONTROL;..\BSP\IIC;..\BSP\IMU;..\BSP\LED;..\BSP\MOTOR;..\BSP\MPU6050;..\BSP\PWM_IN;..\BSP\TIM;..\BSP\UART;..\BSP\Delay;..\BSP\HMC5883;..\BSP\ADC;..\BSP\KEY;..\BSP\OLED;..\BSP\APP;..\BSP\PARAM;..\BSP\NRF24L01;..\BSP\SPI;..\BSP\MS5611;..\BSP\EEPROM;..\BSP\CONGIG;..\BSP\EXTI;..\BSP\PPM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUPCODE
    ../CMSIS/startup/: startup_stm32f10x_hd.s
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group FWlib
    ../FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYS
    ./: main.c stm32f10x_it.c
  group BSP
    ../BSP/LED/: led.c
    ../BSP/KEY/: KEY.c
    ../BSP/OLED/: oled.c
    ../BSP/TIM/: time.c
    ../BSP/Delay/: delay.c
    ../BSP/PWM_IN/: Tim_PWM_IN.c
    ./: page.c PPM.c
  group APP
    ../BSP/APP/: app.c
    ../BSP/CONGIG/: config.c
