# Keil uVision project Demo.uvprojx, settings and files
target Demo (ARM-ADS)
  device: STM32F427VI STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Demo
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F427_437xx, __FPU_PRESENT=1, __FPU_USED =1, ARM_MATH_CM4, __CC_ARM
  c include: ..\CMSIS\Device\ST\STM32F4xx\Include;..\CMSIS\Device\ST\STM32F4xx\Source\Templates\arm;..\STM32F4xx_Driver\inc;..\User;..\BSP;..\FATFS\src;..\FATFS\exfuns;..\MALLOC;..\Algorithm
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Startup
    ../CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f427_437xx.s
  group User
    ./: main.c stm32f4xx_it.c
  group STM32F4xx_Driver
    ../STM32F4xx_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_spi.c stm32f4xx_sdio.c stm32f4xx_tim.c stm32f4xx_dma.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_syscfg.c stm32f4xx_wwdg.c
  group BSP
    ../BSP/: spi.c mpu6000.c sys.c delay.c tim.c sdio_sdcard.c led.c l3gd20h.c lsm303d.c spi2.c TCA62724.c communication.c bsp.c
    ./: PPM.c
  group FATFS
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/src/option/: cc936.c
    ../FATFS/exfuns/: exfuns.c fattester.c
  group MALLOC
    ../MALLOC/: malloc.c
  group history
    ../history/: history.txt
  group ALGORITHM
    ../Algorithm/: Filtering_Algorithm.c Attitude_Algorithm.c Math_Algorithm.c Control_Algorithm.c
